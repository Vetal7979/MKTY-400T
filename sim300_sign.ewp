# IAR project sim300_sign.ewp, settings and files
configuration MKTY-400 (AVR)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0x3ff
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm64.xcl
  group (top)
    ./: main.c
